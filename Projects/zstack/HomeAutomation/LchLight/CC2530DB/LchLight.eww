<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\LchLight.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>LchLight</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>LchLight</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>LchLight</project>
        <configuration>EndDeviceEB</configuration>
      </member>
      <member>
        <project>LchLight</project>
        <configuration>RouterZLight</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


